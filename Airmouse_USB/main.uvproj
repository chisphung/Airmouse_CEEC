# Keil uVision project main.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: main
  c flags: Optim=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\lib;.\sys;.\user;.\user\exti;.\user\tim;.\user\adc;.\user\pwm;.\user\spi&iic;.\user\mpu6050;.\user\kalman;.\user\dac;.\user\screen;.\user\ov7670;.\user\sdcard;.\user\bmp;.\usb;.\usb_lib\inc;.\usb_lib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group lib
    ./lib/: STM32_lib_3.0.lib
  group sys
    ./sys/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group user
    ./user/: main.c stm32f10x_it.c stm32f10x_conf.h gpio.c usart.c delay.c
  group spi&iic
    ./user/spi&iic/: iic.c nrf24l01.c 24cxx.c spi.c
  group tim
    ./user/tim/: tim.c
  group usb
    ./usb/: hw_config.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c platform_config.h
  group usb_lib
    ./usb_lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
