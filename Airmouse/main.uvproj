# Keil uVision project main.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: main
  c flags: Optim=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\lib;.\sys;.\user;.\user\exti;.\user\tim;.\user\adc;.\user\pwm;.\user\spi&iic;.\user\mpu6050;.\user\kalman;.\user\dac;.\user\screen;.\user\ov7670;.\user\sdcard;.\user\bmp;.\usb;.\usb_lib\inc;.\usb_lib\src;.\user\tpad
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ./lib/: STM32_lib_3.0.lib
  group sys
    ./sys/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group user
    ./user/: main.c stm32f10x_it.c stm32f10x_conf.h gpio.c usart.c delay.c
  group mpu6050
    ./user/mpu6050/: mpu6050.c
  group spi&iic
    ./user/spi&iic/: iic.c spi.c nrf24l01.c 24cxx.c
  group tim
    ./user/tim/: tim.c
  group adc
    ./user/adc/: adc.c
